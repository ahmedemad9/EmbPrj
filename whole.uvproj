# Keil uVision project whole.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: whole
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: array.c CalcGPSDistance.c checkDist.c delayMs.c LED_init.c main.c parcing.c Seven_init.c ssd_v2.c UART_init.c UART2_Receiver.c startup_TM4C123.s tm4c123gh6pm.h
